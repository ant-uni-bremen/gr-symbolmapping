options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: symbol_mapping_demo
    output_language: python
    title: Symbol Mapping Demo
  states: {}

blocks:
- name: constellation_order
  id: variable
  parameters:
    comment: |-
      Constellation order is defines the number of bits mapped to 1 complex symbol.

      1: BPSK
      2: QPSK
      4: 16:QAM
      6: 64QAM
      8: 256QAM

      cf. ETSI 138.211 - V15.3.0, 5G NR: Physical channels and modulation
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32000 * 2
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '-1'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '260'
  states: {}
- name: symbolmapping_symbol_demapper_cf_0
  id: symbolmapping_symbol_demapper_cf
  parameters:
    constellation_order: constellation_order
    constellation_type: GRAY
    snr_tag_name: snr
  states: {}
- name: symbolmapping_symbol_mapper_bc_0
  id: symbolmapping_symbol_mapper_bc
  parameters:
    constellation_order: constellation_order
    constellation_type: GRAY
    is_packed: 'True'
  states: {}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_float_to_char_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0, '0', symbolmapping_symbol_mapper_bc_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0, '0']
- [symbolmapping_symbol_demapper_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [symbolmapping_symbol_mapper_bc_0, '0', qtgui_const_sink_x_0, '0']
- [symbolmapping_symbol_mapper_bc_0, '0', symbolmapping_symbol_demapper_cf_0, '0']

metadata:
  file_format: 1

options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: interleaver_demo
    output_language: python
    title: Interleaver Demo
  states: {}

blocks:
- name: intl_indices
  id: variable
  parameters:
    value: np.random.permutation(160)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: symbolmapping_interleaver_0
  id: symbolmapping_interleaver
  parameters:
    interleaver_indices: intl_indices
    interleaver_mode: interleave
    is_packed: '1'
    type: float
  states: {}
- name: symbolmapping_interleaver_0_0
  id: symbolmapping_interleaver
  parameters:
    interleaver_indices: intl_indices
    interleaver_mode: deinterleave
    is_packed: '1'
    type: float
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', symbolmapping_interleaver_0, '0']
- [symbolmapping_interleaver_0, '0', symbolmapping_interleaver_0_0, '0']
- [symbolmapping_interleaver_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
